# Keil uVision project Main.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: XLZN +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c include: ..\User;..\System\sys;..\System\usart;..\System\delay;..\Hardware\KEY;..\Hardware\OLED;..\Hardware\ADC;..\Hardware\MOTOR;..\Hardware\ENCODER;..\Hardware\IIC;..\Hardware\DMP;..\Hardware\MPU6050;..\Hardware\EXTI;..\Hardware\LED;..\Hardware\PS2;..\Hardware\DMA;..\Hardware\CAN
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group User
    ./: Main.c
  group System
    ../System/delay/: delay.c
    ../System/sys/: sys.c
    ../System/usart/: usart.c
  group Hardware
    ../Hardware/ADC/: adc.c
    ../Hardware/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Hardware/ENCODER/: encoder.c
    ../Hardware/EXTI/: exti.c
    ../Hardware/IIC/: IOI2C.c
    ../Hardware/KEY/: key.c
    ../Hardware/LED/: LED.C
    ../Hardware/MOTOR/: motor.c
    ../Hardware/MPU6050/: MPU6050.c
    ../Hardware/OLED/: oled.c
    ../Hardware/PS2/: pstwo.c
    ../Hardware/DMA/: DMA.c
    ../Hardware/CAN/: can.c
software components: CMSIS:CORE 5.4.0
